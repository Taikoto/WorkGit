# Keil uVision project gunlock.uvproj, settings and files
target gun_lock (ARM-ADS)
  device: M0516LDN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: gunlock +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=4
  c include: ..\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group SOURCE
    ./: main.c
  group COMMON
    ../Common/: common.c retarget.c startup_M051.s
  group SEG
    ./: 74ls164.c
  group HX711
    ./: hx711.c
  group I2C
    ./: i2c.c
  group RS485
    ./: rs485.c
  group LED
    ./: led.c
  group LOCK
    ./: lock.c
  group WATCHDOG
    ./: watchdog.c
  group TIMER
    ./: timer.c
  group README
    ./: readme.txt
